## meta/conf/distro/include/yocto-space-optimize.inc
```bitbake
DEBUG_LEVELFLAG:pn-llvm = ""
DEBUG_LEVELFLAG:pn-qemu = "-g"
DEBUG_LEVELFLAG:pn-openssl = "-g"
```
